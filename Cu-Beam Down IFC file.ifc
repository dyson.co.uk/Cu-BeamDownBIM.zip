Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2017-07-10T14:48:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160512_1515(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Mon Jul 10 14:48:07 2017* Host: ncl-PI11* Database: C:\Users\batyg\AppData\Local\Temp\{BD9E5CFF-FF1B-46E2-B2BF-4F4EE1A7DE9D}\ifc* Database version: 5507* Database creation date: Mon Jul 10 14:48:00 2017* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Mon Jul 10 14:48:01 2017* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Mon Jul 10 14:48:02 2017* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFlowTerminal: CU-Beam Down-Light (Exposed driver box) 3000K, NBS_Dyson_GnrlPrpseLmnrs_CUBeam_DownLight:CU-Beam Down-Light (Exposed driver box) 3000K:251664
In: Level 0
Type - Classification: Pr_70_70_48_85 (Uniclass2015); Material: NBS_Concept, NBS_Black
Type - Pset_LightFixtureTypeCommon - NumberOfSources: 1; TotalWattage: 0 W; LightFixtureMountingType: Ceiling pendant; LightFixturePlacingType: n/a; MaintenanceFactor: 0; ManufacturersSpecificInformation: n/a; ArticleNumber: n/a
Type - NBS_General - Author: NBS; BIMObjectName: NBS_Dyson_GeneralPurposeLuminaires_CU-Beam_DownLight_Exposed_3000K; ManufacturerName: Dyson; ManufacturerURL: www.dyson.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/b0prdfd3; NBSDescription: General purpose luminaires; NBSReference: 90-60-50/405; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSTypeID: n/a; ProductInformation: www.dyson.co.uk/lighting/cu-beam-suspended-lights; Revision: n/a; Uniclass2015Title: Surface luminaires; Uniclass2015Code: Pr_70_70_48_85; Uniclass2015Version: Products v1.6; Version: 1
Type - NBS_Data - Standards: IEC/EN 60598-2-1 (Including national deviations); ElectricShockClassification: Control Gear (Class I), luminaire (SELV CLASS III), total product (Class I),; PhotometricPerformance: n/a; SupplyCircuitConductorConnections: n/a; InternalFuse: 4A; InputVoltage: 100-240 V; LuminairePowerFactor: 0.9; LuminaireType: Pendant; IngressProtection: IP20; BallastsCelmaEnergyEfficiencyIndex: n/a; ControlGearPosition: Remote; Lampsnumber: 1; Lampstype: LED; LampscolourTemperature: 3000 K, 4000 K; LampscolourRenderingIndex: Minimum 80; DimmingControlOptions: DALI; FlickerRating: >1% at 400Hz; Lampsrating: 57 W
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no; InsulationStandardClass: Mains input to output = Reinforced, Mains input to enclosure = Basic (Protective earth, Class I); IP_Code: Indoor use only; NominalFrequencyRange: 50/60 Hz; PhaseReference: n/a
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Lighting Fixtures; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: n/a; DurationUnit: year; ExpectedLife: n/a; Features: Heat pipe technology, chip on board LED, trim shutters for optimum framing and glare control; Finish: n/a; Grade: n/a; Material: Aluminium; Manufacturer: specification@dyson.com; ModelNumber: n/a; ModelReference: CU-Beam Down-Light; Name: GeneralPurposeLuminaires_CU-BeamDown-Light_Dyson; NominalHeight: 0 mm; NominalLength: 720 mm; NominalWidth: 0 mm; ReplacementCost: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: 5 years; WarrantyDurationLabor: n/a; WarrantyDurationParts: 5; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: www.dyson.co.uk/support
Pset_ElectricalDeviceCommon - NumberOfPoles: 0; NominalCurrent: 0 A; UsageCurrent: 0 A; NominalVoltage: 0 V; ElectricalDeviceNominalPower: 0 W
Pset_ManufacturerTypeInformation - ArticleNumber: n/a; ModelReference: CU-Beam Down-Light; Manufacturer: specification@dyson.com
Pset_DistributionFlowElementCommon - Reference: CU-Beam Down-Light (Exposed driver box) 3000K
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59; IfcExportAs: IfcLightFixtureType
